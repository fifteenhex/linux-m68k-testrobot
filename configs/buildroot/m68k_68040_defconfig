## configs/buildroot/m68k_68040_defconfig
```kconfig
BR2_m68k=y
BR2_m68k_68040=y
# BR2_TARGET_ROOTFS_TAR is not set
BR2_TARGET_ROOTFS_CPIO=y
BR2_TARGET_ROOTFS_CPIO_LZ4=y
```
